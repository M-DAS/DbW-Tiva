# Keil uVision project throttle.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: throttle
  c flags: Optim=1
  c include: C:\ti\TivaWare_C_Series-2.1.4.178;C:\ti\TivaWare_C_Series-2.1.4.178\driverlib;C:\ti\TivaWare_C_Series-2.1.4.178\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup.s main.c Globals_and_Defines.c initialization.c Tick_Timer.c Switches_PORTF.c CAN_comm.c Pedal_ADC.c Drive_by_Pedal.c Digital_Pot.c Drive_by_Wire.c Linear_Actuator.c PID_Cntl.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
